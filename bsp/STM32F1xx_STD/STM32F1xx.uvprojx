# Keil uVision project STM32F1xx.uvprojx, settings and files
target Project_Name (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ExecutableFile +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: ..\..\app;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\DeviceSupport\startup;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\drivers;..\STM32F1xx_STD;..\..\module;..\..\os;..\..\app\user;..\..\module\utils;..\..\module\fifo;..\..\module\radio\inc;..\..\module\radio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group bsp
    ./drivers/: bsp.c stm32_usart.c
    ./: stm32f10x_it.c
  group app
    ../../app/: main.c
    ./: config.h
  group Library
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_bkp.c misc.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_exti.c
  group os
    ../../os/: cola_os.c cola_device.c cola_init.c
  group app/usr
    ../../app/user/: app.c app_uart.c
  group module
    ../../module/fifo/: cola_fifo.c
    ../../module/utils/: utils.c
